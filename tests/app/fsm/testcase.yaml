## tests/app/fsm/testcase.yaml
```yaml
common:
  tags: fsm
  integration_platforms:
    - qemu_cortex_m0
tests:
  app.fsm: {}
```
